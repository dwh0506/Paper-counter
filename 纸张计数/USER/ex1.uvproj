# Keil uVision project ex1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: ex1 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\SYSTEM;..\HARDWARE;..\USER
  group User
    ./: main.c myself.c
  group SYS
    ../SYSTEM/: Serial.c AD.c STC8EEPROM.c
  group Hardware
    ../HARDWARE/: FDC2214.c oled.c
  group Note
    ../Note/: 说明.txt
